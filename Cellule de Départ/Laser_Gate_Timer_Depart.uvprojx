# Keil uVision project Laser_Gate_Timer_Depart.uvprojx, settings and files
target Laser_Gate_Timer_Depart (6070000::V6.7::.\ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: Laser_Gate_Timer_Depart
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: DEVICE_SERIAL=1 COMPONENT_FLASHIAP=1 __MBED__=1 MBED_MINIMAL_PRINTF DEVICE_MPU=1 DEVICE_SPI_ASYNCH=1 DEVICE_RTC=1 TRANSACTION_QUEUE_SIZE_SPI=2 TARGET_STM32F411xE DEVICE_USTICKER=1 DEVICE_PORTOUT=1 TARGET_RELEASE DEVICE_I2CSLAVE=1 __MBED_CMSIS_RTOS_CM DEVICE_SERIAL_FC=1 DEVICE_LPTICKER=1 DEVICE_SPI=1 TOOLCHAIN_ARMC6 USE_HAL_DRIVER __ASSERT_MSG TARGET_LIKE_CORTEX_M4 TARGET_RTOS_M4_M7 TARGET_FF_ARDUINO STM32F411xE TARGET_NAME=NUCLEO_F411RE DEVICE_SERIAL_ASYNCH=1 __CMSIS_RTOS TARGET_FF_MORPHO DEVICE_STDIO_MESSAGES=1 __CORTEX_M4 USE_FULL_LL_DRIVER DEVICE_RESET_REASON=1 TARGET_STM32F4 MBED_RAM_SIZE=0x20000 MBED_ROM_START=0x8000000 MBED_TRAP_ERRORS_ENABLED=1 DEVICE_I2C=1 TARGET_NUCLEO_F411RE DEVICE_WATCHDOG=1 MBED_BUILD_TIMESTAMP=1623050740.316398 TOOLCHAIN_ARM_STD TARGET_MCU_STM32 DEVICE_SLEEP=1 DEVICE_I2C_ASYNCH=1 DEVICE_ANALOGIN=1 DEVICE_PORTINOUT=1 MBED_RAM_START=0x20000000 DEVICE_SPISLAVE=1 TARGET_CORTEX_M TARGET_M4 DEVICE_INTERRUPTIN=1 DEVICE_FLASH=1 DEVICE_PWMOUT=1 TARGET_CORTEX TOOLCHAIN_ARM MBED_ROM_SIZE=0x80000 MULADDC_CANNOT_USE_R7 ARM_MATH_CM4 __FPU_PRESENT=1 DEVICE_PORTIN=1 TARGET_STM TARGET_LIKE_MBED
  c misc: -mfloat-abi=hard -Wno-armcc-pragma-push-pop -fno-rtti --target=arm-arm-none-eabi -fno-exceptions -fdata-sections -mthumb -mcpu=cortex-m4 -mfpu=fpv4-sp-d16 -Wno-reserved-user-defined-literal -Wno-armcc-pragma-anon-unions -c -fno-c++-static-destructors -Wno-deprecated-register -fshort-enums -fshort-wchar -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;BLE_API;BLE_API/ble;BLE_API/ble/services;X_NUCLEO_IDB0XA1;X_NUCLEO_IDB0XA1/x-nucleo-idb0xa1;X_NUCLEO_IDB0XA1/x-nucleo-idb0xa1/bluenrg-hci;X_NUCLEO_IDB0XA1/x-nucleo-idb0xa1/platform;X_NUCLEO_IDB0XA1/x-nucleo-idb0xa1/utils;mbed;mbed/TARGET_NUCLEO_F411RE/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-DARM_MATH_CM4,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DSTM32F411xE,-D__MBED_CMSIS_RTOS_CM,-DUSE_HAL_DRIVER,-D__CORTEX_M4,-DUSE_FULL_LL_DRIVER,-D__FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .link_script.sct
  link misc: --predefine="-DMBED_BOOT_STACK_SIZE=4096" --predefine="-DXIP_ENABLE=0" --legacyalign --show_full_path --predefine="-DMBED_ROM_SIZE=0x80000" --any_contingency --inline --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_SIZE=0x20000" --keep=os_cb_sections --cpu=Cortex-M4 --predefine="-DMBED_RAM_START=0x20000000"
  group BLE_API
    BLE_API/ble/services/: BatteryService.h DeviceInformationService.h DFUService.h EddystoneConfigService.h EddystoneService.h EnvironmentalService.h HealthThermometerService.h HeartRateService.h iBeacon.h LinkLossService.h UARTService.h URIBeaconConfigService.h
    BLE_API/source/: BLE.cpp BLEInstanceBase.cpp DiscoveredCharacteristic.cpp GapScanningParams.cpp
    BLE_API/ble/: BLE.h blecommon.h BLEInstanceBase.h BLEProtocol.h CallChainOfFunctionPointersWithContext.h CharacteristicDescriptorDiscovery.h deprecate.h DiscoveredCharacteristic.h DiscoveredCharacteristicDescriptor.h DiscoveredService.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GapScanningParams.h GattAttribute.h GattCallbackParamTypes.h GattCharacteristic.h GattClient.h GattServer.h GattServerEvents.h GattService.h SafeBool.h SecurityManager.h ServiceDiscovery.h UUID.h
    BLE_API/source/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
  group Laser_Gate_Timer_Depart
    ./: main.cpp mbed_config.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_F411RE/TOOLCHAIN_ARM_STD/: analogin_api.o analogin_device.o analogout_api.o analogout_device.o arm_math.h can_api.o can_device.h cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_version.h common_objects.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h device.h except.o flash_api.o flash_data.h gpio_api.o gpio_irq_api.o gpio_irq_device.h gpio_irq_device.o gpio_object.h hal_tick_overrides.o i2c_api.o i2c_device.h lp_ticker.o mbed.ar mbed_board.o mbed_cmsis_conf.h mbed_crc_api.o mbed_fault_handler.h mbed_fault_handler.o mbed_overrides.o mbed_retarget.o mbed_rtx.h mbed_sdk_boot.o mbed_tz_context.o mpu_armv7.h mpu_armv8.h nvic_addr.h objects.h PeripheralNames.h PeripheralPins.h PeripheralPins.o pin_device.h pinmap.o PinNames.h PinNamesTypes.h port_api.o PortNames.h pwmout_api.o pwmout_device.h pwmout_device.o qspi_api.o rtc_api.o rtc_api_hal.h RTE_Components.h serial_api.o serial_api_hal.h serial_device.o sleep.o spi_api.o spi_device.h startup_stm32f411xe.o stm32_assert.h stm32_hal_legacy.h stm32f411xe.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal.o stm32f4xx_hal_adc.h stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.h stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.h stm32f4xx_hal_can.o stm32f4xx_hal_can_legacy.h stm32f4xx_hal_can_legacy.o stm32f4xx_hal_cec.h stm32f4xx_hal_cec.o stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.h stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.h stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.h stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.h stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.h stm32f4xx_hal_eth.o stm32f4xx_hal_flash.h stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio.o stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.h stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.h stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.h stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.h stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_mmc.h stm32f4xx_hal_mmc.o stm32f4xx_hal_nand.h stm32f4xx_hal_nand.o stm32f4xx_hal_nor.h stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.h stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.h stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.h stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.h stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.h stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.h stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.h stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.h stm32f4xx_hal_spi.o stm32f4xx_hal_sram.h stm32f4xx_hal_sram.o stm32f4xx_hal_tim.h stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.h stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.h stm32f4xx_hal_uart.o stm32f4xx_hal_usart.h stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.h stm32f4xx_hal_wwdg.o stm32f4xx_ll_adc.h stm32f4xx_ll_adc.o stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_crc.o stm32f4xx_ll_dac.h stm32f4xx_ll_dac.o stm32f4xx_ll_dma.h stm32f4xx_ll_dma.o stm32f4xx_ll_dma2d.h stm32f4xx_ll_dma2d.o stm32f4xx_ll_exti.h stm32f4xx_ll_exti.o stm32f4xx_ll_fmc.h stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.h stm32f4xx_ll_fsmc.o stm32f4xx_ll_gpio.h stm32f4xx_ll_gpio.o stm32f4xx_ll_i2c.h stm32f4xx_ll_i2c.o stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_lptim.o stm32f4xx_ll_pwr.h stm32f4xx_ll_pwr.o stm32f4xx_ll_rcc.h stm32f4xx_ll_rcc.o stm32f4xx_ll_rng.h stm32f4xx_ll_rng.o stm32f4xx_ll_rtc.h stm32f4xx_ll_rtc.o stm32f4xx_ll_sdmmc.h stm32f4xx_ll_sdmmc.o stm32f4xx_ll_spi.h stm32f4xx_ll_spi.o stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_tim.o stm32f4xx_ll_usart.h stm32f4xx_ll_usart.o stm32f4xx_ll_usb.h stm32f4xx_ll_usb.o stm32f4xx_ll_utils.h stm32f4xx_ll_utils.o stm32f4xx_ll_wwdg.h stm_spi_api.o system_clock.o system_stm32f4xx.h system_stm32f4xx.o trng_api.o tz_context.h us_ticker.o us_ticker_data.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h CThunkBase.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_crash_data_offsets.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/: mbed.h
  group X_NUCLEO_IDB0XA1
    X_NUCLEO_IDB0XA1/source/platform/: ble_clock.c btle.cpp stm32_bluenrg_ble.cpp
    X_NUCLEO_IDB0XA1/x-nucleo-idb0xa1/bluenrg-hci/: ble_clock.h ble_compiler.h ble_debug.h ble_gp_timer.h ble_hal.h ble_hal_types.h ble_hci.h ble_hci_const.h ble_link_layer.h ble_list.h ble_osal.h ble_sm.h ble_status.h bluenrg_aci.h bluenrg_aci_const.h bluenrg_gap.h bluenrg_gap_aci.h bluenrg_gatt_aci.h bluenrg_gatt_server.h bluenrg_hal_aci.h bluenrg_l2cap_aci.h bluenrg_updater_aci.h bluenrg_utils.h
    X_NUCLEO_IDB0XA1/source/bluenrg-hci/utils/: ble_gp_timer.c ble_list.c ble_osal.c
    X_NUCLEO_IDB0XA1/source/bluenrg-hci/hci/: ble_hci.c
    X_NUCLEO_IDB0XA1/source/utils/: ble_payload.cpp ble_utils.cpp
    X_NUCLEO_IDB0XA1/x-nucleo-idb0xa1/utils/: ble_payload.h ble_utils.h
    X_NUCLEO_IDB0XA1/source/bluenrg-hci/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils.c
    X_NUCLEO_IDB0XA1/source/: BlueNRGDevice.cpp BlueNRGDiscoveredCharacteristic.cpp BlueNRGGap.cpp BlueNRGGattClient.cpp BlueNRGGattServer.cpp
    X_NUCLEO_IDB0XA1/x-nucleo-idb0xa1/: BlueNRGDevice.h BlueNRGDiscoveredCharacteristic.h BlueNRGGap.h BlueNRGGattClient.h BlueNRGGattServer.h x_nucleo_idb0xa1_targets.h
    X_NUCLEO_IDB0XA1/x-nucleo-idb0xa1/platform/: btle.h stm32_bluenrg_ble.h
